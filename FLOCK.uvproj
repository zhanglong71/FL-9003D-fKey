# Keil uVision project FLOCK.uvproj, settings and files
target Target 1 (MCS-51)
  device: P87C51RA2 Philips
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(33000000) MODP2
  output: FLOCK +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c PRO.C FIGER.C IAP.c ADC.c
  group OS
    ./: OS.c
